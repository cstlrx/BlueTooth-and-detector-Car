# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: findroadcar +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\HARDWEAR\KEY;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWEAR\LED;..\HARDWEAR\TimerPWM;..\HARDWEAR\detectors;..\HARDWEAR\LCD;..\HARDWEAR\HC05;..\USMART;..\HARDWEAR\USART2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWEAR/LED/: led.c
    ../HARDWEAR/KEY/: key.c
    ../HARDWEAR/TimerPWM/: motor.c
    ../HARDWEAR/detectors/: detector.c
    ../HARDWEAR/HC05/: hc05.c
    ../HARDWEAR/USART2/: usart2.c
